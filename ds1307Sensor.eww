<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\Downloads\1-Simple-GPIO\1 - Simple GPIO\STM8SF103F3\Simple GPIO - STM8S103F3.ewp</path>
    </project>
    <project>
        <path>E:\stm8\st1\st1.ewp</path>
    </project>
    <batchBuild />
</workspace>
